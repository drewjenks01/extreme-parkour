Commit message: add textures

File: legged_gym/experiment/mesh_generation/parkour_meshes/rectangular_prism_bumps.urdf (robot description, URDF)
Before this commit: robot mesh, 1 links, 0 joints
Links:
- link mesh: geometry visual mesh filename=rectangular_prism_bumps.obj
