Commit message: updates

File: legged_gym/experiment/mesh_generation/parkour_meshes/whole_map/_prototype.urdf (robot description, URDF)
Before this commit: robot _name, 1 links, 0 joints
Links:
- link _name: geometry visual mesh filename=_prototype.obj scale=1 1 1
